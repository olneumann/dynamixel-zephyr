## zephyr/Kconfig
```kconfig
config DYNAMIXEL
	bool "DYNAMIXEL SDK Enable"
	default n
	depends on SERIAL
	help
		ROBOTIS Dynamixel API Enable
```
